## boards/arm/ad44/Kconfig.board
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config BOARD_ad44
	bool "ad44"
	depends on SOC_NRF52840_QIAA
```
